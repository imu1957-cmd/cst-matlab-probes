# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\TUYA;..\CLOCK\RTC;..\CLOCK\SHT30;..\CLOCK\WS2812;..\CLOCK\AT24C02;..\CLOCK\HV57708;..\CLOCK\LCD;..\CLOCK;..\CLOCK\LINK;..\CLOCK\UI;..\CLOCK\LED;..\CLOCK\EXT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../CLOCK/: control.c
    ../CLOCK/LINK/: clock_link.c clock_link.h link_proto.c
    ../CLOCK/UI/: screen_ui.c screen_ui.h
  group HARDWARE
    ../HARDWARE/: usart_init.c usart_init.h timer_init.c timer_init.h iic_init.c iic_init.h
  group CLOCK
    ../CLOCK/EXT/: ext_env.c ext_env.h ext_demo.c ext_demo.h ext_pomo.c ext_pomo.h ext_repeat.c ext_repeat.h ext_diag.h ext_diag.c ext_weather.c ext_weather.h ext_linkstat.c ext_linkstat.h
    ../CLOCK/RTC/: rtc.c rtc.h
    ../CLOCK/SHT30/: sht30.c sht30.h
    ../CLOCK/WS2812/: ws2812b_init.c ws2812b_init.h
    ../CLOCK/AT24C02/: 24Cxx_init.c 24Cxx_init.h
    ../CLOCK/HV57708/: HV57708.c HV57708.h
    ../CLOCK/LCD/: lcd.c lcd.h lcd_init.c lcdfont.h pic.h
    ../CLOCK/UI/: codec.c codec_gbk_table.c codec.h screen_cfg.c screen_cfg.h
  group LED
    ../CLOCK/LED/: led_fx.c led_fx.h
  group TUYA
    ../TUYA/: mcu_api.c mcu_api.h protocol.c protocol.h system.c system.h wifi.h
